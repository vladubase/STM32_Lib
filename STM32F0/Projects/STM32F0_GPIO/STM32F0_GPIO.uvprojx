# Keil uVision project STM32F0_GPIO.uvprojx, settings and files
target STM32F0_GPIO (6140001::V6.14.1::ARMCLANG)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F0_GPIO +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\STM32F0_GPIO;.\CMSIS\inc;.\Code\inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Startup
    ./Startup/: startup_stm32f030.s
  group CMSIS
    ./CMSIS/src/: system_stm32f0xx.c
  group Code
    ./Code/src/: main.c InitRCC.c InitGPIO.c InitSWD.c
