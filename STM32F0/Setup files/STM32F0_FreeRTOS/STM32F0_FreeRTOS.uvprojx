# Keil uVision project STM32F0_FreeRTOS.uvprojx, settings and files
target STM32F0_FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F0_FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\STM32F0_FreeRTOS;.\CMSIS\inc;.\Code\inc;.\FreeRTOS\inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Startup
    ./Startup/: startup_stm32f030.s
  group CMSIS
    ./CMSIS/src/: system_stm32f0xx.c
  group Code
    ./Code/src/: main.c InitRCC.c InitSWD.c InitGPIO.c
  group FreeRTOS
    ./FreeRTOS/src/: croutine.c event_groups.c heap_1.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
