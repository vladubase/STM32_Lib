# Keil uVision project STM32F1_I2C.uvprojx, settings and files
target STM32F1_I2C (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F1_I2C +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=2
  c include: ..\STM32F1_I2C;.\CMSIS\inc;.\Code\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS/src/: system_stm32f10x.c
  group Code
    ./Code/src/: main.c InitRCC.c InitSWD.c InitI2C.c InitGPIO.c
